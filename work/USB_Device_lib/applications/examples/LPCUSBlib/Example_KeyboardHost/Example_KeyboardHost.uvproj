# Keil uVision project Example_KeyboardHost.uvproj, settings and files
target MCB1700 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: KeyBoardHost_MCB1700
  c flags: Optim=1 OneElfS=1
  c define: __LPC17XX__ USB_HOST_ONLY
  c misc: --gnu --c99 --diag_suppress=1207,2776
  c include: ..\..\..\..\libraries\LPCUSBlib\Drivers\USB;..\..\..\..\libraries\BSP;..\..\..\..\libraries\CDL\CMSISv2p00_LPC17xx\inc;..\..\..\..\libraries\CDL\LPC17xxLib\inc;..\..\..\..\libraries\LPCUSBlib\Drivers\USB\Class\Common
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group src
    ./: KeyboardHost.c readme.txt
  group lib
    ../../../../libraries/BSP/keil_output/: BSP_MCB1700.lib BSP_MCB1800.lib BSP_MCB4300.lib BSP_HITEX1850.lib BSP_HITEX4350.lib BSP_XPLORER1830.lib BSP_XPLORER4330.lib BSP_EAOEMBaseRevA_LPC177x_8x.lib
    ../../../../libraries/CDL/keil_output/: CDL_LPC177x_8x.lib CDL_LPC17xx.lib CDL_LPC18xx.lib CDL_LPC43xx.lib
    ../../../../libraries/LPCUSBlib/keil_output/: LPCUSBlib_LPC177x_8x_Host.lib LPCUSBlib_LPC17xx_Host.lib LPCUSBlib_LPC18xx_Host.lib LPCUSBlib_LPC43xx_Host.lib
target MCB1800 (ARM-ADS)
  device: LPC1850 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10017FFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: KeyboardHost_MCB1800 +hex
  c flags: Optim=1 OneElfS=1
  c define: CORE_M3 __LPC18XX__ USB_HOST_ONLY
  c misc: --gnu --c99 --diag_suppress=1207,2776
  c include: ..\..\..\..\libraries\LPCUSBlib\Drivers\USB;..\..\..\..\libraries\BSP;..\..\..\..\libraries\CDL\CMSISv2p00_LPC18xx\inc;..\..\..\..\libraries\CDL\LPC18xxLib\inc
  asm define: NO_CRP
  memory RVCT4: ROM 0x10080000 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x18000
  memory RVCT10: RAM 0x20000000 size 0x10000
target MCB4300 (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: KeyboardHost_MCB4300 +hex
  c flags: Optim=1 OneElfS=1
  c define: __LPC43XX__ USB_HOST_ONLY
  c misc: --gnu --c99 --diag_suppress=1207,2776
  c include: ..\..\..\..\libraries\LPCUSBlib\Drivers\USB;..\..\..\..\libraries\BSP;..\..\..\..\libraries\CDL\CMSISv2p00_LPC43xx\inc;..\..\..\..\libraries\CDL\LPC43xxLib\inc;..\..\..\..\libraries\CDL\CMSISv2p00_LPC43xx\lpcinc
  asm define: NO_CRP
  memory RVCT4: ROM 0x10000000 size 0x18000
  memory RVCT9: RAM 0x10080000 size 0xa000
target HITEX1850 (ARM-ADS)
  device: LPC1850 NXP (founded by Philips)
  cpu: as above
  output: KeyboardHost_HITEX1850 +hex
  c flags: Optim=1 OneElfS=1
  c define: CORE_M3 __LPC18XX__ USB_HOST_ONLY
  c misc: --gnu --c99 --diag_suppress=1207,2776
  c include: ..\..\..\..\libraries\LPCUSBlib\Drivers\USB;..\..\..\..\libraries\BSP;..\..=\..\..\libraries\CDL\CMSISv2p00_LPC18xx\inc;..\..\..\..\libraries\CDL\LPC18xxLib\inc
  asm define: NO_CRP
  memory RVCT4: ROM 0x10080000 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x18000
  memory RVCT10: RAM 0x20000000 size 0x10000
target HITEX4350 (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: KeyboardHost_HITEX4350 +hex
  c flags: Optim=1 OneElfS=1
  c define: __LPC43XX__ USB_HOST_ONLY
  c misc: --gnu --c99 --diag_suppress=1207,2776
  c include: as above
  asm define: NO_CRP
  memory RVCT4: ROM 0x10000000 size 0x18000
  memory RVCT9: RAM 0x10080000 size 0xa000
target XPLORER1830 (ARM-ADS)
  device: LPC1830 NXP (founded by Philips)
  cpu: as above
  output: KeyboardHost_XPLORER1830 +hex
  c flags: Optim=1 OneElfS=1
  c define: __LPC18XX__ USB_HOST_ONLY
  c misc: --gnu --c99 --diag_suppress=1207,2776
  c include: as above
  asm define: NO_CRP
  memory RVCT4: ROM 0x10000000 size 0x18000
  memory RVCT9: RAM 0x10080000 size 0xa000
  memory RVCT10: RAM 0x20000000 size 0x10000
target XPLORER4330 (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: KeyboardHost_XPLORER4330 +hex
  c flags: Optim=1 OneElfS=1
  c define: __LPC43XX__ USB_HOST_ONLY
  c misc: --gnu --c99 --diag_suppress=1207,2776
  c include: as above
  asm define: NO_CRP
  memory RVCT4: ROM 0x10000000 size 0x18000
  memory RVCT9: RAM 0x10080000 size 0xa000
target EAOEMBaseRevA_LPC177x_8x (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: KeyBoardHost_EAOEMBaseRevA_LPC177x_8x
  c flags: Optim=1 OneElfS=1
  c define: __LPC177X_8X__ USB_HOST_ONLY
  c misc: --gnu --c99 --diag_suppress=1207,2776
  c include: ..\..\..\..\libraries\LPCUSBlib\Drivers\USB;..\..\..\..\libraries\BSP;..\..\..\..\libraries\CDL\CMSISv2p00_LPC177x_8x\inc;..\..\..\..\libraries\CDL\LPC177x_8xLib\inc;..\..\..\..\libraries\LPCUSBlib\Drivers\USB\Class\Common;..\..\..\..\libraries\CDL\CMSISv2p00_LPC177x_8x\lpcinc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\LPC177x_8x.sct

# IAR project Example_KeyboardHostDevice.ewp, settings and files
configuration MCB1700 (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __LPC17XX__; USB_DEVICE_ONLY
  ICCARM.CCIncludePath2: ..\..\..\..\libraries\LPCUSBlib\Drivers\USB; ..\..\..\..\libraries\BSP; ..\..\..\..\libraries\CDL\LPC17xxLib\inc; ..\..\..\..\libraries\CDL\CMSISv2p00_LPC17xx\lpcinc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Example_MassStorageDevice.srec
  ILINK.IlinkOutputFile: Example_MassStorageDevice.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration LPC1788_EAOEMBaseRevA (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1788 NXP LPC1788
  ICCARM.CCDefines: __LPC177X_8X__; USB_DEVICE_ONLY
  ICCARM.CCIncludePath2: ..\..\..\..\libraries\LPCUSBlib\Drivers\USB; ..\..\..\..\libraries\BSP; ..\..\..\..\libraries\CDL\CMSISv2p00_LPC177x_8x\inc; ..\..\..\..\libraries\CDL\LPC177x_8xLib\inc; ..\..\..\..\libraries\CDL\CMSISv2p00_LPC177x_8x\lpcinc
configuration LPC1850_HITEX_A4 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1850 NXP LPC1850
  ICCARM.CCDefines: __LPC18XX__
  ICCARM.CCIncludePath2: ..\..\..\..\libraries\LPCUSBlib\Drivers\USB; ..\..\..\..\libraries\BSP; ..\..\..\..\libraries\CDL\CMSISv2p00_LPC18xx\inc; ..\..\..\..\libraries\CDL\LPC18xxLib\inc; ..\..\..\..\libraries\CDL\CMSISv2p00_LPC18xx\lpcinc
configuration LPC1857_MCB1800 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1857 NXP LPC1857
  ICCARM.CCDefines: __LPC18XX__
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: LPC1857_4357_iram.icf
configuration HITEX_LPC4350_M4_IRAM (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4350_M4 NXP LPC4350_M4
  ICCARM.CCDefines: __LPC43XX__
  ICCARM.CCIncludePath2: ..\..\..\..\libraries\LPCUSBlib\Drivers\USB; ..\..\..\..\libraries\BSP; ..\..\..\..\libraries\CDL\CMSISv2p00_LPC43xx\inc; ..\..\..\..\libraries\CDL\LPC43xxLib\inc; ..\..\..\..\libraries\CDL\CMSISv2p00_LPC43xx\lpcinc
configuration LPC4357_MCB4300 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4357_M4 NXP LPC4357_M4
  ICCARM.CCDefines: __LPC43XX__
  ICCARM.CCIncludePath2: ..\..\..\..\libraries\LPCUSBlib\Drivers\USB; ..\..\..\..\libraries\BSP; ..\..\..\..\libraries\CDL\LPC43xxLib\inc; ..\..\..\..\libraries\CDL\CMSISv2p00_LPC43xx\lpcinc
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkIcfFile: LPC1857_4357_iram.icf
configuration Xplorer1830 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1830 NXP LPC1830
  ICCARM.CCDefines: __LPC18XX__
  ICCARM.CCIncludePath2: as above
configuration Xplorer4330 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4330_M4 NXP LPC4330_M4
  ICCARM.CCDefines: __LPC43XX__
  ICCARM.CCIncludePath2: as above
  group (top)
    ./: Descriptors.c Keyboard.c KeyboardHost.c readme.txt
  group Libraries
    ../../../../libraries/BSP/LPC11u14_MCB1000/Exe/: BSP_LPC11u14_MCB1000.a
    ../../../../libraries/BSP/LPC1768_MCB1700/Exe/: BSP_LPC1768_MCB1700.a
    ../../../../libraries/BSP/LPC1788_EAOEMBaseRevA/Exe/: BSP_LPC1788_EAOEMBaseRevA.a
    ../../../../libraries/BSP/LPC1830_XPLORER/Exe/: BSP_LPC1830_XPLORER.a
    ../../../../libraries/BSP/LPC1850_HITEX_A4/Exe/: BSP_LPC1850_HITEX_A4.a
    ../../../../libraries/BSP/LPC1857_MCB1800/Exe/: BSP_LPC1857_MCB1800.a
    ../../../../libraries/BSP/LPC4330_Xplorer/Exe/: BSP_LPC4330_Xplorer.a
    ../../../../libraries/BSP/LPC4350_HITEX_A4/Exe/: BSP_LPC4350_HITEX_A4.a
    ../../../../libraries/BSP/LPC4357_MCB4300/Exe/: BSP_LPC4357_MCB4300.a
    ../../../../libraries/CDL/LPC11Uxx/Exe/: CDL_LPC11Uxx.a
    ../../../../libraries/CDL/LPC177x_8x/Exe/: CDL_LPC177x_8x.a
    ../../../../libraries/CDL/LPC17xx/Exe/: CDL_LPC17xx.a
    ../../../../libraries/CDL/LPC18xx/Exe/: CDL_LPC18xx.a
    ../../../../libraries/CDL/LPC43xx_M4/Exe/: CDL_LPC43xx_M4.a
    ../../../../libraries/LPCUSBLib/LPC18xx_DeviceHost/Exe/: LPCUSBlib_LPC18xx_DeviceHost.a
    ../../../../libraries/LPCUSBLib/LPC43xx_DeviceHost/Exe/: LPCUSBlib_LPC43xx_DeviceHost.a

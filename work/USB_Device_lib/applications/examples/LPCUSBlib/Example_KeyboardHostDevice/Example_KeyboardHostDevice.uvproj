# Keil uVision project Example_KeyboardHostDevice.uvproj, settings and files
target MCB1000 (ARM-ADS)
  device: LPC11U14/201 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: KeyBoardDevice_MCB1000
  c flags: OneElfS=1
  c define: __LPC11UXX__ USB_DEVICE_ONLY
  c misc: --gnu --c99 --diag_suppress=1207,2776
  c include: ..\..\..\..\libraries\LPCUSBlib\Drivers\USB;..\..\..\..\libraries\BSP;..\..\..\..\libraries\CDL\CMSISv2p00_LPC11Uxx\inc;..\..\..\..\libraries\CDL\LPC11UxxLib\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  scatter file: .\LPC11Uxx.sct
  group src
    ./: Descriptors.c Keyboard.c readme.txt KeyboardHost.c
    ./Lib/: UsbRom.c
  group lib
    ../../../../libraries/BSP/keil_output/: BSP_MCB1000.lib BSP_MCB1700.lib BSP_MCB1800.lib BSP_MCB4300.lib BSP_HITEX1850.lib BSP_HITEX4350.lib BSP_XPLORER1830.lib BSP_XPLORER4330.lib BSP_EAOEMBaseRevA_LPC177x_8x.lib
    ../../../../libraries/CDL/keil_output/: CDL_LPC11Uxx.lib CDL_LPC177x_8x.lib CDL_LPC17xx.lib CDL_LPC18xx.lib CDL_LPC43xx.lib
    ../../../../libraries/LPCUSBLib/keil_output/: LPCUSBlib_LPC18xx_HostDevice.lib LPCUSBlib_LPC17xx_HostDevice.lib
target MCB1700 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: KeyboardDevice_MCB1700
  c flags: Optim=1 OneElfS=1
  c define: __LPC17XX__
  c misc: --gnu --c99 --diag_suppress=1207,2776
  c include: ..\..\..\..\libraries\LPCUSBlib\Drivers\USB;..\..\..\..\libraries\BSP;..\..\..\..\libraries\CDL\CMSISv2p00_LPC17xx\inc;..\..\..\..\libraries\CDL\LPC17xxLib\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target MCB1800 (ARM-ADS)
  device: LPC1857 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: KeyboardHostDevice_MCB1800 +hex
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1A000000)
  AfterMake: fromelf --bin -o "@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1
  c define: __LPC18XX__
  c misc: --gnu --c99 --diag_suppress=1207,2776
  c include: ..\..\..\..\libraries\LPCUSBlib\Drivers\USB;..\..\..\..\libraries\BSP;..\..\..\..\libraries\CDL\CMSISv2p00_LPC18xx\inc;..\..\..\..\libraries\CDL\LPC18xxLib\inc
  asm define: NO_CRP
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
target MCB4300 (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: KeyboardDevice_MCB4300 +hex
  c flags: Optim=1 OneElfS=1
  c define: __LPC43XX__ USB_DEVICE_ONLY
  c misc: --gnu --c99 --diag_suppress=1207,2776
  c include: ..\..\..\..\libraries\LPCUSBlib\Drivers\USB;..\..\..\..\libraries\BSP;..\..\..\..\libraries\CDL\CMSISv2p00_LPC43xx\inc;..\..\..\..\libraries\CDL\LPC43xxLib\inc;..\..\..\..\libraries\CDL\CMSISv2p00_LPC43xx\lpcinc
  asm define: NO_CRP
  memory RVCT4: ROM 0x10000000 size 0x18000
  memory RVCT9: RAM 0x10080000 size 0xa000
target HITEX1850 (ARM-ADS)
  device: LPC1850 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10017FFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: KeyboardDevice_HITEX1850 +hex
  c flags: Optim=1 OneElfS=1
  c define: __LPC18XX__ USB_DEVICE_ONLY
  c misc: --gnu --c99 --diag_suppress=1207,2776
  c include: as above
  asm define: NO_CRP
  memory RVCT4: ROM 0x10000000 size 0x18000
  memory RVCT9: RAM 0x10080000 size 0xa000
  memory RVCT10: RAM 0x20000000 size 0x10000
target HITEX4350 (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: KeyboardDevice_HITEX4350 +hex
  c flags: Optim=1 OneElfS=1
  c define: __LPC43XX__ USB_DEVICE_ONLY
  c misc: --gnu --c99 --diag_suppress=1207,2776
  c include: as above
  asm define: NO_CRP
  memory RVCT4: ROM 0x10000000 size 0x18000
  memory RVCT9: RAM 0x10080000 size 0xa000
target XPLORER1830 (ARM-ADS)
  device: LPC1830 NXP (founded by Philips)
  cpu: as above
  output: KeyboardDevice_XPLORER1830 +hex
  c flags: Optim=1 OneElfS=1
  c define: __LPC18XX__ USB_DEVICE_ONLY
  c misc: --gnu --c99 --diag_suppress=1207,2776
  c include: as above
  asm define: NO_CRP
  memory RVCT4: ROM 0x10000000 size 0x18000
  memory RVCT9: RAM 0x10080000 size 0xa000
  memory RVCT10: RAM 0x20000000 size 0x10000
target XPLORER4330 (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: KeyboardDevice_XPLORER4330 +hex
  c flags: Optim=1 OneElfS=1
  c define: __LPC43XX__ USB_DEVICE_ONLY
  c misc: --gnu --c99 --diag_suppress=1207,2776
  c include: as above
  asm define: NO_CRP
  memory RVCT4: ROM 0x10000000 size 0x18000
  memory RVCT9: RAM 0x10080000 size 0xa000
target EAOEMBaseRevA_LPC177x_8x (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: KeyBoardDevice_EAOEMBaseRevA_LPC177x_8x
  c flags: OneElfS=1
  c define: __LPC177X_8X__
  c misc: --gnu --c99 --diag_suppress=1207,2776
  c include: ..\..\..\..\libraries\LPCUSBlib\Drivers\USB;..\..\..\..\libraries\BSP;..\..\..\..\libraries\CDL\CMSISv2p00_LPC177x_8x\inc;..\..\..\..\libraries\CDL\LPC177x_8xLib\inc;..\..\..\..\libraries\CDL\CMSISv2p00_LPC177x_8x\lpcinc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\LPC177x_8x.sct
